# Keil uVision project CAS_MX.uvprojx, settings and files
target CAS_MX (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: CAS_MX +hex
  AfterMake: fromelf --text -a -c --output=CAS_MX.dis C:\Users\WhiteKite2020\Desktop\CAS_MX\MDK-ARM\CAS_MX\CAS_MX.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../SYSTEM/sys;../SYSTEM/usart;../HARDWARE/LED;../HARDWARE/KEY;../HARDWARE/EXTI;../HARDWARE/WDG;../HARDWARE/TIMER;../HARDWARE/TPAD;../HARDWARE/OLED;../HARDWARE/SDRAM;../HARDWARE/CAN;../HARDWARE/RS485;../HARDWARE/PCF8574;../HARDWARE/24CXX;../HARDWARE/SPI;../USER;../HARDWARE/st7789;../HARDWARE/W5500;../SYSTEM/hal_delay;../HARDWARE/IC_MB4;../CANOpen/include/STM32;../CANOpen/src;../CANOpen/include;../CANOpen/objdic;../USER/utils;../USER/luenberger
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/24CXX/: 24cxx.c myiic.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/W5500/: socket.c w5500.c wizchip_conf.c
    ../HARDWARE/IC_MB4/: mb4_1sf_driver.c
    ../HARDWARE/ST7789/: lcd.c lcd_init.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/hal_delay/: hal_delay.c
  group USER
    ../USER/: pid.c sysTime.c userApp.c
    ../USER/luenberger/: luenberger_observer.c
    ../USER/utils/: matrix.c
  group CANOpen
    ../CANOpen/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c canfestival_can.c canfestival_timer.c
    ../CANOpen/objdic/: canfestival_master.c
software components: CMSIS:CORE 4.3.0
